# Keil uVision project CT117E-LCD.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CT117E-LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,_1010MODE
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group Library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_usart.c stm32f10x_dma.c
  group LCD_Driver
    ../Sre/: lcd.c
  group User
    ../Sre/: main.c stm32f10x_it.c led.c tim.c buzzer.c key.c i2c.c adc.c rtc.c pwm.c pwm_octoggle.c InputCapture.c uart_idle_rxne.c tim1.c
